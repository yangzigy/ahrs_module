# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: MCU_PROJ
  c include: .\app;.\hal;.\src;.\sys;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ./sys/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f10x_hd.s stm32f1_sys.c stm32f1_sys.h stm32f10x.h system_stm32f10x.h
  group src
    ./src/: main.c cmd.c cmd.h main.h queue.c queue.h uart.c uart.h
  group app
    ./app/: ahrsv2.cpp ahrsv2.h app.cpp config.c config.h
  group hal
    ./hal/: i2c.c i2c.h led.c led.h mpu6050.c mpu6050.h f1_flash.c f1_flash.h qmc5883l.c qmc5883l.h i2c1.c i2c1.h
  group common
    ../common/: com_fun.c com_fun.h comm_rec.c comm_rec.h geometric.cpp geometric.h
